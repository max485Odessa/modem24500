# Keil uVision project modem4800.uvprojx, settings and files
target txrx (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: modem4800
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: STM32F103x6,HSE_VALUE=8000000
  c include: .\src\drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/drivers/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c system_stm32f1xx.c startup_stm32f103x6.s stm32f1xx_hal_dma.c
    ./src/: app.cpp TBITMODEM.cpp rutine.cpp hard_rut.cpp
